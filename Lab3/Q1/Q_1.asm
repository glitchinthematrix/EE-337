;--------
;Author: BHISHMA DEDHIA
;NAME: LED TOGGLE
;--------

LED1 equ P1.7
LED2 equ P1.6
LED3 equ P1.5

ORG 00H
LJMP MAIN
;------------
ORG 50H
	MAIN:
	MOV A,#4
	MOV B,#2
	DIV AB
	MOV 4FH,A
	CLR P1.4
	LOOP:
		SETB LED1
		SETB LED2
		SETB LED3
		LCALL DELAY
		CLR LED3
		LCALL DELAY
		SETB LED3
		CLR LED2
		LCALL DELAY
		CLR LED3
		LCALL DELAY
		SETB LED3
		SETB LED2
		CLR LED1
		LCALL DELAY
		CLR LED3
		LCALL DELAY
		SETB LED3
		CLR LED2
		LCALL DELAY
		CLR LED3
		LCALL DELAY
		SJMP LOOP
;------------	
	
	DELAY: 
	SETB PSW.5
		   MOV R3, 4FH
	BACK3: 
		   MOV R4, #10
	BACK2:	   
		   MOV R5,#200
	BACK1:
		   MOV R1,#0FFH
	BACK:
		   DJNZ R1, BACK
		   DJNZ R5, BACK1
		   DJNZ R4, BACK2
		   DJNZ R3, BACK3
		   CLR PSW.5
	   RET
END