;--------
;AUTHOR:BHISHMA DEDHIA
;TITLE:SQUARE ROOT
;--------

ORG 00H
LJMP MAIN
ORG 50H
	FINDSQRT:
		MOV R1,A
		MOV B,#02
		DIV AB
		MOV R3,A
		MOV A,R2
		MOV B,R1
		DIV AB
		MOV B,#02
		DIV AB
		MOV 40H,R3
		;INC R4
		;CJNE R4,#81 ,EXIT
		ADD A,R3
		MOV 40H,R1
		CJNE A,40H,FINDSQRT
		RET
	
	MAIN:
		MOV 50H,#0B9H
		MOV R2,50H
		MOV A,#1
		LCALL FINDSQRT
		MOV A,R1
		MOV B,R1
		MUL AB
		CJNE A,50H,DISPLAYSIGNIBBLE
		MOV A, R1
		SWAP A
		MOV P1,A
		SJMP HERE
		DISPLAYSIGNIBBLE:
		MOV P1,50H
		HERE:
		SJMP HERE
END